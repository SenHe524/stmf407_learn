# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c misc: --gnu
  c include: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\STM32F4xx\Include;..\Libraries\CMSIS\Device\STM32F4xx\Source;..\Libraries\CMSIS\Device\STM32F4xx\Source\arm;..\User;..\User\sys;..\User\delay;..\User\usart;..\User\flash;..\User\canopen\src;..\User\canopen\inc;..\User\canopen\inc\stm;..\User\canopen\hardware;..\User\canopen\dictionary;..\User\imu
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/STM32F4xx/Source/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Libraries/CMSIS/Device/STM32F4xx/Source/: system_stm32f4xx.c
  group Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CANopen
    ../User/canopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../User/canopen/inc/: data.h
  group CANopen_Driver
    ../User/canopen/dictionary/: Master.c
    ../User/canopen/hardware/: can1.c can1.h timer_user.c timer_user.h config.h pdo_set.c pdo_set.h set_get_info.c set_get_info.h
    ../User/canopen/inc/stm/: timerscfg.h applicfg.h
  group USER
    ../User/: main.c main.h
    ../User/delay/: delay.c delay.h
    ../User/sys/: sys.c sys.h
    ../User/usart/: usart.c usart.h protocol.c protocol.h
    ../User/canopen/hardware/: hardware_driver.c hardware_driver.h
    ../User/flash/: stmflash.c stmflash.h
    ../User/imu/: imu.c imu.h
